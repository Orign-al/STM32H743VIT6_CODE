# Keil uVision project LED.uvprojx, settings and files
target LED (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx
  c include: ..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32H7xx_HAL_Driver\Inc;..\HARDWARE\LED;..\Middlewares\include;..\Middlewares\portable\RVDS\ARM_CM7\r0p1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group USER
    ./: main.c stm32h7xx_it.c system_stm32h7xx.c stm32h7xx_hal_msp.c FreeRTOSConfig.h
  group CORE
    ../CORE/: core_cm7.h cmsis_armcc.h cmsis_compiler.h startup_stm32h743xx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HALLIB
    ../HALLIB/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
  group README
    ../: readme.txt
  group Middlewares/FreeRTOS_CORE
    ../Middlewares/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../Middlewares/portable/MemMang/: heap_4.c
    ../Middlewares/portable/RVDS/ARM_CM7/r0p1/: port.c
